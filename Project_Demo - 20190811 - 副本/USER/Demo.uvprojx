# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: STM32_FFT +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\BSP;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\SPI;..\HARDWARE\HMC472A;..\HARDWARE\PE4302;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\KEY;..\HARDWARE\AD9959;..\HARDWARE\TIMER;..\HARDWARE\UART4;..\HARDWARE\USART6;..\HARDWARE\DAC;..\HARDWARE\ADC;..\HARDWARE\ADF4351;..\HARDWARE\ESP8266;..\DSP_Lib\CMSIS\Include;..\DSP_FFT\inc;..\DSP_Lib\CMSIS\DSP_Lib\Examples\arm_linear_interp_example\ARM;..\HARDWARE\MB1504;..\HARDWARE\CH9121;..\APP;..\HARDWARE\AD9833
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group APP
    ../APP/: app.c
  group BSP
    ../BSP/: bsp.c bsp_dsp_fft.c
  group Drivers
    ../HARDWARE/LCD/: bsp_lcd.c
    ../HARDWARE/OLED/: bsp_oled.c
    ../HARDWARE/LED/: bsp_led.c
    ../HARDWARE/SPI/: bsp_spi.c
    ../HARDWARE/KEY/: bsp_key.c
    ../HARDWARE/HMC472A/: bsp_hmc472a.c
    ../HARDWARE/PE4302/: bsp_pe4302.c
    ../HARDWARE/MB1504/: bsp_mb1504.c
    ../HARDWARE/AD9959/: bsp_ad9959.c
    ../HARDWARE/ADF4351/: bsp_adf4351.c
    ../HARDWARE/UART4/: bsp_uart4.c
    ../HARDWARE/USART6/: bsp_uart6.c
    ../HARDWARE/CH9121/: bsp_ch9121.c
    ../HARDWARE/AD9833/: AD9833_SPI.c
  group DA/AD
    ../HARDWARE/DAC/: bsp_dac.c
    ../HARDWARE/ADC/: bsp_adc.c
  group TIMER
    ../HARDWARE/TIMER/: bsp_timer.c
  group WIFI
    ../HARDWARE/ESP8266/: bsp_esp8266.c
  group TOUCH
    ../HARDWARE/TOUCH/: bsp_touch.c bsp_ft6236.c bsp_ctiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSP_LIB
    ../DSP_Lib/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group DSP_FFT
    ../DSP_FFT/src/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s arm_fft_bin_data.c
    ../DSP_FFT/inc/: stm32_dsp.h table_fft.h
  group README
    ../README/: readme.txt
